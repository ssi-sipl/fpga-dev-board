# Repository ssi-sipl/fpga-dev-board

## KiCad design VhARIO-ESPC3/vhario-espc3.kicad_pcb

File VhARIO-ESPC3/README.md:

# VhARIO-ESPC3 Rev B

Kicad 6 circuit schematic and PCB layout for an audio variometer using ESP32-C3 and CJMCU-117 IMU modules. The vario uses a Kalman filter to fuse acceleration data and pressure altitude data for 'zero-lag' response. You can find the [firmware project here](https://github.com/har-in-air/ESP32C3_BLUETOOTH_AUDIO_VARIO).

2-layer PCB sized for [Hammond 1551K 80x40x20 mm enclosure](docs/1551K.pdf).

Li-poly battery recharging via USB-C.

ESP32-C3 flash and debug via built-in USB serial jtag peripheral.

All SMD passive components use Kicad hand-solderable footprints.

All component symbols and footprints used in the project are in project-specific libraries in the `/libraries` folder.

## Hardware

* AI-Thinker  ESP-C3 12F module (C3FN4) with 4MByte flash.
* CJMCU-117 IMU module (MPU9250 + MS5611).
* 74HC240 used as push-pull piezo speaker driver.
* 1800mAH Li-Poly battery.
* MCP73871 battery charger @ 500mA max.
* Soft-switched power on/off via SW3.
* USB serial jtag programming and debug via USB-C interface. The flash/debug jumper can be a PCM12 slide switch (SW2) on the bottom layer if you want access from outside the enclosure. Or you can solder a 2.54mm pitch header with a jumper cap (JP1) on the top layer. The jumper is shorted only for flash/debug and is open for normal vario operation.

## Schematic
[Schematic PDF](docs/vhario-espc3-schematic.pdf)

## Differences between Rev A and Rev B hardware
* The Rev A archive can be found in the releases section.
* Rev B is a Kicad 6 project (6.0.6 as of date). Rev A was unfortunately developed with the Kicad 6.99 development branch. This is incompatible with the Kicad 6 project file format. The Rev A project can only be opened with a Kicad 6.99 development build from 2022 Jan 26 or later.
* Flash and debug in Rev B uses the ESP32-C3 built-in USB serial jtag peripheral with a jumper or slide switch (JP1/SW2). For Rev A hardware, an external USB-UART adapter and jumper/switch is required. 
* For Rev B, all smd components except for a couple of modules have been placed on one side of the PCB to facilitate automated assembly.
* For Rev B, the power/bluetooth LED and charging status LED are placed together so only one enclosure LED window is required.
* The [firmware](https://github.com/har-in-air/ESP32C3_BLUETOOTH_AUDIO_VARIO) can be configured to support either Rev A or Rev B hardware. The configuration options are in the `platformio.ini` file.

## Kicad 3D view

## Assembly

# Credits

Prototype design, component sourcing and PCB assembly in collaboration with Benoit Arnal.

Parts:
BZ1: KPEG006; conn_smd_1x2_2mm
C1, C2, C3, C9, C10, C11, C13: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C5: 22u 16V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C6: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C8: 100u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C12, C14, C15: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D2: CHRG; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: PWR; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4, D6, D7: BV03C; D_SOD-323_HandSoldering
D5: 1N5819WS; D_SOD-323_HandSoldering
F1: nSMD100-16; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
H1, H2: MountingHole; MountingHole_2.5mm
J1: USB_C; usb_c_16
J2: Battery; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
JP1: DBG; PinSocket_1x02_P2.54mm_Vertical
L1, L2: GZ2012D601TF; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Q1: AO3401A; SOT-23
Q2: 2N7002; SOT-23
R1, R8, R10, R11, R12, R13, R15, R16: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 5K1 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R7: 2K7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 2K2; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R9, R14: 2K2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: RST; smd_btn4
SW2: DBG; SW_SPDT_PCM12
SW3: PWR; smd_btn4
SW4: PCCA; smd_btn4
U1: cjmcu117
U2: MCP73831-2-OT; SOT-23-5
U3: espc3fn4
U4: 74HC240PWR; SSOP-20_4.4x6.5mm_P0.65mm
U5: TLV75533PDBV; SOT-23-5

Connections:
+3V3: C7.1, C8.1, C13.1, C15.1, D7.2 (A2), R5.1, R9.2, R11.1, R15.1, U3.8 (vcc), U5.5 (OUT)
+BATT: C5.1, J2.1, JP1.1 (A), Q1.2 (S), R10.1, SW2.1 (A), SW3.1, SW3.2, U2.3 (VBAT); also elsewhere on the board
+VSW: C3.1, C12.1, C14.1, D5.1 (K), L1.2, Q1.3 (D), R13.1, U4.20 (VCC), U5.1 (IN), U5.3 (EN)
/ADC: C11.1, R13.2, R14.1, U3.1 (io0)
/AUDIO: U3.13 (io7), U4.2 (1A0), U4.4 (1A1), U4.6 (1A2), U4.8 (1A3)
/AUDIO_EN: R15.2, U3.12 (io6), U4.1 (1OE), U4.19 (2OE)
/CSB: U1.9 (csb), U3.21 (io20)
/D+: D6.1 (A1), J1.6 (d+), J1.8 (d+), U3.20 (d+)
/D-: D4.1 (A1), J1.5 (d-), J1.7 (d-), U3.19 (d-)
/DRDY: R1.1, U1.7 (int), U3.4 (io2)
/MISO: U1.6 (ad0), U1.8 (sdo), U3.2 (io1)
/MOSI: U1.4 (sda), U3.6 (io4)
/NCS: U1.5 (ncs), U3.5 (io3)
/PWR_CTRL: Q2.1 (G), R12.1, U3.17 (io10)
/PWR_SENS: C9.1, R7.2, R8.1, U3.22 (io21)
/SCK: U1.3 (scl), U3.7 (io5)
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, D4.2 (A2), D6.2 (A2), D7.1 (A1), J1.1 (gnd), J1.12 (gnd), J2.2, L2.1, Q2.2 (S), R1.2, R2.2, R3.2, R4.1, R8.2, R12.2, R14.2, SW1.1, SW1.2, SW4.3 (K), SW4.4 (A), U1.10 (ps), U2.2 (VSS), U3.15 (gnd), U4.10 (GND), U5.2 (GND); also elsewhere on the board
unnamed: BZ1.1 (-), R16.1, U4.11 (2A3), U4.12 (1Y3), U4.13 (2A2), U4.14 (1Y2), U4.15 (2A1), U4.16 (1Y1), U4.17 (2A0), U4.18 (1Y0)
unnamed: BZ1.2 (+), R16.2, U4.3 (2Y0), U4.5 (2Y1), U4.7 (2Y2), U4.9 (2Y3)
unnamed: C1.1, J1.16 (s4)
unnamed: C2.1, L1.1, U1.1 (vcc)
unnamed: C2.2, L2.2, U1.2 (gnd)
unnamed: C4.1, D2.2 (A), F1.2, U2.4 (VDD)
unnamed 23: C6.1, R5.2, SW1.3 (K), SW1.4 (A), U3.3 (en); also elsewhere on the board
unnamed 24: C10.1, R11.2, SW4.1, SW4.2, U3.18 (io9); also elsewhere on the board
unnamed: D2.1 (K), R6.2
unnamed: D3.1 (K), U3.16 (io8)
unnamed: D3.2 (A), R9.1
unnamed 28: D5.2 (A), JP1.2 (B), R7.1, SW2.2 (B), SW3.3 (K), SW3.4 (A); also elsewhere on the board
unnamed: F1.1, J1.2 (vbus), J1.11 (vbus)
unnamed: J1.4 (cc1), R2.1
unnamed: J1.10 (cc2), R3.1
unnamed: Q1.1 (G), Q2.3 (D), R10.2
unnamed: R4.2, U2.5 (PROG)
unnamed: R6.1, U2.1 (STAT)

Board: 2 copper layers, 74.0 x 34.0 mm, 57 parts (50 on the bottom side), 35 nets.

Other parts of the board:
PCCA: PCCA; smd_btn4
PWR: PWR; smd_btn4
RST: RST; smd_btn4

Their connections:
+BATT: PWR.1, PWR.2; also elsewhere on the board
GND: PCCA.3 (K), PCCA.4 (A), RST.1, RST.2; also elsewhere on the board
unnamed 23: RST.3 (K), RST.4 (A); also elsewhere on the board
unnamed 24: PCCA.1, PCCA.2; also elsewhere on the board
unnamed 28: PWR.3 (K), PWR.4 (A); also elsewhere on the board
